# Keil uVision project Pro.uvprojx, settings and files
target Pro (5050169::V5.05 update 2 (build 169)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Pro +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,ARM_MATH_CM4,STM32F40_41xxx
  c include: ..\App;..\BSP;..\Module;..\CMSIS\Core;..\UCOS\Source;..\UCOS\Port;..\CMSIS\Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../App/: Main.c Task_Test.c Task_VoiceControl.c
  group BSP
    ../BSP/: LED.C Bsp_Global.c DMA.C NVIC.C SCI.c adc.c exchangeSpeaker.C optoswitch.c motor.c steeringengine.c
  group Module
    ../Module/: M_CMSIS_P.h M_Delay_P.c M_Delay_P.h M_Global.c M_Global.h M_Type_P.h
  group CMSIS/Core
    ../CMSIS/Core/: arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h startup_stm32f4xx.s system_stm32f4xx.h stm32f4xx_conf.h arm_cortexM4lf_math.lib system_stm32f4xx.c stm32f4xx.h
  group UCOS/Port
    ../UCOS/Port/: app_cfg.h os_cfg.h os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c ucosii_inc.h
  group UCOS/Source
    ../UCOS/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group CMSIS/Driver
    ../CMSIS/Driver/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
software components: CMSIS:CORE 4.1.0
